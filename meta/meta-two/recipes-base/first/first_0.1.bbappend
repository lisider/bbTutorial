python do_patch () {
	  bb.note ("do_patch")
}
 
addtask patch before do_build
